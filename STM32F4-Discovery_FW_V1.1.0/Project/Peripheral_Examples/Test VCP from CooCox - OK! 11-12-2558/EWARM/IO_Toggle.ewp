# IAR project IO_Toggle.ewp, settings and files
configuration Sender (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: F:\Google Drive\GitHub\STM32F4-Project\STM32F4-Discovery_FW_V1.1.0\Project\Peripheral_Examples\Test VCP from CooCox - OK! 11-12-2558\cmsis; F:\Google Drive\GitHub\STM32F4-Project\STM32F4-Discovery_FW_V1.1.0\Project\Peripheral_Examples\Test VCP from CooCox - OK! 11-12-2558\cmsis_boot; F:\Google Drive\GitHub\STM32F4-Project\STM32F4-Discovery_FW_V1.1.0\Project\Peripheral_Examples\Test VCP from CooCox - OK! 11-12-2558\cmsis_lib\include; F:\Google Drive\GitHub\STM32F4-Project\STM32F4-Discovery_FW_V1.1.0\Project\Peripheral_Examples\Test VCP from CooCox - OK! 11-12-2558\usb_conf; F:\Google Drive\GitHub\STM32F4-Project\STM32F4-Discovery_FW_V1.1.0\Project\Peripheral_Examples\Test VCP from CooCox - OK! 11-12-2558\usb_lib\cdc; F:\Google Drive\GitHub\STM32F4-Project\STM32F4-Discovery_FW_V1.1.0\Project\Peripheral_Examples\Test VCP from CooCox - OK! 11-12-2558\usb_lib\core; F:\Google Drive\GitHub\STM32F4-Project\STM32F4-Discovery_FW_V1.1.0\Project\Peripheral_Examples\Test VCP from CooCox - OK! 11-12-2558\usb_lib\otg
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IO_Toggle.srec
  ILINK.IlinkOutputFile: IO_Toggle.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group User
    ../: main.c startup_stm32f4xx.s
    ../cmsis_lib/source/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c
    ../cmsis_boot/: system_stm32f4xx.c
    ../usb_conf/: usb_bsp.c usbd_desc.c usbd_usr.c
    ../usb_lib/otg/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../usb_lib/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
    ../usb_lib/core/: usbd_core.c usbd_ioreq.c usbd_req.c
